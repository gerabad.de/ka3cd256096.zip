Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_46_x3Z31/format_0/3254(architecture=300).ifc
Time: 2025-09-01T09:05:53
Made in: PARTsolutions

# IfcProject, 3254(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3254(architecture=300)
In: BUILDING
Description: 3254(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3254
ePset_PARTsolutions - NB: 3254(architecture=300); NN: 3254; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3254(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3254; B: 3254_aluvia_1000x800.png; C: ALUVIA; E: KALDEWEI; EF000049: 1000; EF004567: 800; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 800; etim7_EC003246_LENGTH: 1000
